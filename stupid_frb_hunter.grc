<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>stupid_frb_hunter</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Analysis_Poller</value></param>
<param><key>block_id</key><value>Stupid_FRB</value></param>
<param><key>function_name</key><value>doAnalysis</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_lower</value></param>
<param><key>value</key><value>(skyf-srate/2.0)/1.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_upper</value></param>
<param><key>value</key><value>(skyf+srate/2.0)/1.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbrate</value></param>
<param><key>value</key><value>4000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbsize</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ichans</value></param>
<param><key>value</key><value>eval(chans)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>minsmear</value></param>
<param><key>value</key><value>dm/2.41e-4 * (1.0/(f_lower*f_lower)-1.0/(f_upper*f_upper))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>outfile</value></param>
<param><key>value</key><value>prefix+"frb-"+str(int(skyf/1.0e6))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(srate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>skyf</value></param>
<param><key>value</key><value>freq if sky &lt;= 0 else sky</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Stupid_FRB</value></param>
<param><key>chans</key><value>ichans</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import time
import json
import math
import Queue
import copy
import os

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """A FRB first-order detector block"""

    def __init__(self, fbsize=16,filename='/dev/null',fbrate=2500,chans=[1,7,14],
        thresh=5.0,minsmear=2.5e-3,declination=0.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Stupid FRB Hunter',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        
        #
        # We create a "work queue" of preliminary events
        #  The dequeue worker does further analysis before
        #  logging the event.
        self.aQueue = Queue.Queue(maxsize=16)
        self.filename = filename
        
        #
        # we (somewhat arbitrarily) inspect a two-second window of
        #  channel data looking for pulses
        #
        self.two_seconds = int(fbrate*2)
        self.channels=[]
        self.chans = chans
        self.lchans = len(chans)
        self.declination = declination
        self.scnt = 0
        self.fbsize = fbsize
        self.fbrate = fbrate
        #
        # The minimum time distance for detected
        #  pulses between the lowest and highest frequency
        #
        self.mindistance = minsmear * float(fbrate)
        self.mindistance = int(self.mindistance)
        for x in range(fbsize):
            self.channels.append([0.0]*self.two_seconds)
            
        self.thresh = thresh
        self.flen = fbsize

    #
    # Log an event
    #
    # We basically log the entire two-second channel buffer
    #
    def logthispuppy(self,chans,evt):
        q = self.thresh
        ltp = time.gmtime(evt)
        frac = evt-float(int(evt))
        declination = -99.00
        if (isinstance(self.declination, str) == True):
            if (os.path.isfile(self.declination)):
                f = open(self.declination, "r")
                dstr=f.readline()
                f.close()
                declination = float(dstr)
            else:
                try:
                    declination = float(self.declination)
                except:
                    declination = -99.00
        else:
            declination = float(self.declination)
        fn = self.filename+"-"
        fn = fn + "%7.2f-%04d%02d%02d_%02d%02d%05.3f" % (declination, ltp.tm_year, ltp.tm_mon,
            ltp.tm_mday, ltp.tm_hour, ltp.tm_min, float(ltp.tm_sec)+frac)
        fp = open (fn+".dat", "w")
        for c in range(self.lchans):
            fp.write (str(chans[c])+"\n")
        fp.close()
    
    def doAnalysis(self):
        if (self.aQueue.empty()):
            return None
        else:
            item = self.aQueue.get()
            goodcnt = 0
            for chan in item["data"]:
                avg = np.mean(chan)
                mx = np.max(chan)
                if (mx &gt; avg*self.thresh):
                    goodcnt += 1
            if (goodcnt == self.lchans):
                self.logthispuppy(item["data"],item["time"])

    def work(self, input_items, output_items):
        """Do dedispersion/folding"""
        q = input_items[0]
        l = len(q)
        for i in range(int(l/self.flen)):
            bndx = i*self.flen
            for c in range(self.flen):
                self.channels[c][self.scnt] = q[bndx]
                bndx += 1
            self.scnt += 1
            if (self.scnt &gt;= self.two_seconds):
                # Analysis
                amused = 0
                amusingplaces = []
                #
                # For each of the "test" (amusing) channels
                #
                # Test for a spike that is "big" compared to mean
                #  in each of the "test" channels
                #
                for amusing in self.chans:
                    #
                    # Channel average
                    #
                    cavg = np.mean(self.channels[amusing])
                    if ((np.max(self.channels[amusing])) / cavg &gt; self.thresh):
                        amused += 1
                        amusingplaces.append(np.argmax(self.channels[amusing]))
                    else:
                        break
                
                #
                # Only if we were amused in all amusing places
                #
                if (amused &gt;= self.lchans):
                    #
                    # Spike on lower-frequency channel must occur *after*
                    #  higher-frequency channel. Difference in positions
                    #  must be "significant"
                    #
                    if (amusingplaces[0] &gt; amusingplaces[len(amusingplaces)-1] and
                        (amusingplaces[0] - amusingplaces[len(amusingplaces)-1]) &gt; self.mindistance):
                            #
                            # Place this on a deeper-analysis queue
                            #
                            d = {}
                            d["data"] = copy.deepcopy(self.channels)
                            t = time.time()
                            #
                            # Adjust timestamp for pulse location within
                            #  the 2-second window.  This is only very
                            #  approximate.  But potentially allows better
                            #  coordination to other observatories.
                            #
                            t -= (self.amusingplaces[0]*(1.0/self.fbrate))
                            d["time"] = t
                            self.aQueue.put(d)
                self.scnt = 0

        return len(q)
</value></param>
<param><key>comment</key><value>Hunt for FRBs
Look for strong pulses in a select subset of
FFT bins.  Confirm roughly-correct
timing of those pulses. We use a two-second
window to evaluate pulse events.</value></param>
<param><key>declination</key><value>decln</value></param>
<param><key>fbrate</key><value>fbrate</value></param>
<param><key>fbsize</key><value>fbsize</value></param>
<param><key>filename</key><value>outfile</value></param>
<param><key>minsmear</key><value>minsmear</value></param>
<param><key>thresh</key><value>threshold</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>decim</key><value>int(samp_rate/fbsize/fbrate)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>4*fbsize</value></param>
<param><key>n</key><value>5*fbsize</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>comment</key><value>Convert to stream
Hunter will convert back
to vector internally</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chans</value></param>
<param><key>label</key><value>Channels to inspect</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"[1,7,14]"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decln</value></param>
<param><key>label</key><value>Declination</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"-99.0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Device String</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl=0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dm</value></param>
<param><key>label</key><value>Minimum Dispersion Measure</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>150</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>comment</key><value>FFT filterbank</value></param>
<param><key>fft_size</key><value>fbsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fbsize)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>611e6</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>samp_rate*0.8</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>File prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sky</value></param>
<param><key>label</key><value>Sky Frequency if different from tuned freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.56e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Trigger Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.75</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>Stupid_FRB</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
