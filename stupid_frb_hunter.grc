<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>stupid_frb_hunter</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbrate</value></param>
<param><key>value</key><value>2500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbsize</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>flower</value></param>
<param><key>value</key><value>(freq-(samp_rate/2.0))/1.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fupper</value></param>
<param><key>value</key><value>(freq+(samp_rate/2.0))/1.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(srate)</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Stupid_FRB</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import time
import json

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """A pulsar folder/de-dispersion block"""

    def __init__(self, fbsize=16,filename='/dev/null',fbrate=2500,dms=[10.0,20.0,30.0,40.0,50.0],freq=408.0e6,bw=2.56e6,thresh=5.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Stupid FRB Hunter',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        
        self.dmtable=dms
        self.filespec=filename
        self.flen = fbsize
        self.maxdelays = []
        self.delayincrs = []
        flower = (freq-(bw/2.0))/1.0e6
        fupper = (freq+(bw/2.0))/1.0e6
        self.ndms = len(self.dmtable)
        for dm in self.dmtable:
            smear = dm/2.41e-4 * (1.0/(flower*flower)-1.0/(fupper*fupper))
            smear = int(round(smear * fbrate))
            incr = int(round(float(smear)/float(fbsize)))
            self.maxdelays.append(smear)
            self.delayincrs.append(incr)
        self.obufs = np.zeros((self.ndms+1,fbrate))
        self.ocount = 0
        self.thresh = thresh
        print self.maxdelays
        print self.delayincrs
        
    def work(self, input_items, output_items):
        """Do dedispersion/folding"""
        q = input_items[0]
        l = len(q)
        for i in range(l/self.flen):
            bndx = i*self.flen
            
            for x in range(self.ndms):
            #
            # Do delay/dedispersion logic
            #
                if (self.maxdelays[x] &gt; 0):
                    outval = 0.0
                    #
                    # start at 1 because
                    #  we already know maxdelay &gt; 1
                    #
                    for j in range(1,self.flen):
                        if ((self.maxdelays[x] - (self.delayincrs[x]*j)) &lt;= 0):
                            outval += q[bndx+j]
                    self.maxdelays[x] -= 1
                else:
                    outval = sum(q[bndx:bndx+self.flen])
                
                
                self.obufs[x+1][self.ocount] = outval
            
            self.obufs[0][self.ocount] = sum(q[bndx:bndx+self.flen])
            self.ocount += 1
            if (self.ocount &gt;= len(self.obufs[0])):
                self.ocount = 0
                
                for x in range(self.ndms+1):
                    avg = sum(self.obufs[x])
                    avg /= len(self.obufs[x])
                    if ((max(self.obufs[x]) &gt; avg*self.thresh) and x != 0):
                        t = time.gmtime()
                        d = {}
                        d["time"] = "%04d%02d%02d-%02d:%02d:%02d" % (t.tm_year,
                            t.tm_mon, t.tm_mday, t.tm_hour, t.tm_min, t.tm_sec)
                        tseries = []
                        for obuf in self.obufs:
                            tseries.append(list(obuf))
                        d["tseries"] = tseries
                        d["dms"] = [0.0]+self.dmtable
                        d["trigger"] = (x,d["dms"][x])
                        fn = self.filespec+"-"+d["time"]+".json"
                        print "Writing %s" % fn
                        fp = open(fn, "w")
                        fp.write(json.dumps(d, indent=4)+"\n")
                        fp.close()  
                        break                  

            
        return len(q)
</value></param>
<param><key>comment</key><value>Hunt for FRBs
Compute incoherent de-dispersion across
a set of different trial DMs
look for strong pulse</value></param>
<param><key>dms</key><value>[150.0,200.0,250.0,300.0,350.0,400.0,450.0,500.0]</value></param>
<param><key>fbrate</key><value>fbrate</value></param>
<param><key>fbsize</key><value>fbsize</value></param>
<param><key>filename</key><value>outfile</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>thresh</key><value>threshold</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>comment</key><value>Effect spectral inversion--makes some
of the downstream routines easier</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>comment</key><value>Decimate down to output rate</value></param>
<param><key>n</key><value>samp_rate/fbsize/fbrate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>comment</key><value>Convert to stream
Folder will convert back to vector
internally</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Device String</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>comment</key><value>FFT filterbank</value></param>
<param><key>fft_size</key><value>fbsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fbsize)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>408.0e6</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>outfile</value></param>
<param><key>label</key><value>Output file prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>frb-408</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(samp_rate/fbsize/fbrate*0.5)</value></param>
<param><key>comment</key><value>Some light low-pass filtering</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.56e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Trigger Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.5</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>Stupid_FRB</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
